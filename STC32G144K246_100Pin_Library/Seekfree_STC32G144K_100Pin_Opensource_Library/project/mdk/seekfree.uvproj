# Keil uVision project seekfree.uvproj, settings and files
target stc32g144k246 (MCS-251)
  device: AI8052U-32Bit Series AI
  cpu: IRAM(0-0x3FFF) XRAM(0x10000-0x2FFFF) IROM(0xFC0000-0xFFFFFF) CLOCK(35000000)
  output: SEEKFREE +hex
  asm include: ..\..\libraries\zf_common
  link misc: REMOVEUNUSED,NOOVERLAY
  group doc
    ../../libraries/doc/: version.txt
  group zf_common
    ../../libraries/zf_common/: stc32g144k246.h START251.A51 zf_common_headfile.h zf_common_typedef.c zf_common_typedef.h zf_common_clock.c zf_common_clock.h zf_common_interrupt.c zf_common_interrupt.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h
  group zf_driver
    ../../libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_delay.c zf_driver_delay.h zf_driver_eeprom.c zf_driver_eeprom.h zf_driver_encoder.c zf_driver_encoder.h zf_driver_exti.c zf_driver_exti.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h zf_driver_usb_cdc.c zf_driver_usb_cdc.h
  group zf_device
    ../../libraries/zf_device/: zf_device_type.c zf_device_type.h zf_device_config.LIB zf_device_config.h zf_device_mt9v03x.c zf_device_mt9v03x.h zf_device_mt9v03x_dma.LIB zf_device_mt9v03x_dma.h zf_device_ips114.c zf_device_ips114.h zf_device_tft180.c zf_device_tft180.h zf_device_ips200.c zf_device_ips200.h zf_device_ips200pro.c zf_device_ips200pro.h zf_device_ble6a20.c zf_device_ble6a20.h zf_device_wifi_spi.c zf_device_wifi_spi.h zf_device_wireless_uart.c zf_device_wireless_uart.h zf_device_dl1a.c zf_device_dl1a.h zf_device_dl1b.c zf_device_dl1b.h zf_device_imu660ra.c zf_device_imu660ra.h zf_device_imu660rb.c zf_device_imu660rb.h zf_device_imu660rc.c zf_device_imu660rc.h zf_device_imu963ra.c zf_device_imu963ra.h
  group zf_components
    ../../libraries/zf_components/stc32g_usb_lib/: config.h stc.h usb.c usb.h usb_desc.c usb_desc.h usb_req_class.c usb_req_class.h usb_req_std.c usb_req_std.h usb_req_vendor.c usb_req_vendor.h util.c util.h
    ../../libraries/zf_components/seekfree_assistant/: seekfree_assistant.c seekfree_assistant.h seekfree_assistant_interface.c seekfree_assistant_interface.h
  group L0_SYS
    ../L0_SYS/: sys_start.c sys_start.h sys_include.h sys_tfpu.h sys_tfpu.asm
  group L1_BSP
    ../L1_BSP/: bsp_battery.c bsp_battery.h bsp_buzzer.c bsp_buzzer.h bsp_encoder.c bsp_encoder.h bsp_imu.c bsp_imu.h bsp_include.h bsp_inductor.c bsp_inductor.h bsp_motor.c bsp_motor.h
  group L2_SERVICE
    ../L2_SERVICE/: service_batterycheck.c service_batterycheck.h service_buzzer.c service_buzzer.h service_delay.c service_delay.h service_function_queue.c service_function_queue.h service_include.h service_imu.c service_imu.h service_inductor.c service_inductor.h service_negative_pressure.c service_negative_pressure.h service_packet.c service_packet.h service_motor.c service_motor.h service_speed.c service_speed.h service_wireless_uart.c service_wireless_uart.h service_timetick.c service_timetick.h
  group L3_APP
    ../L3_APP/: app_attitude.c app_attitude.h app_battery_guard.c app_battery_guard.h app_include.h app_element.c app_element.h roundabout_priority_tree.c roundabout_priority_tree.h app_feedforward.c app_feedforward.h app_fuzzy_pid.c app_fuzzy_pid.h app_inductor_preprocess.c app_inductor_preprocess.h app_log.c app_log.h app_load_distribution.c app_load_distribution.h app_motion_preprocess.c app_motion_preprocess.h app_motion_postprocess.c app_motion_postprocess.h app_scheduler.c app_scheduler.h app_speed_plan.c app_speed_plan.h app_speedout.c app_speedout.h app_boot_sequence.c app_boot_sequence.h
  group LL_Shared_Source
    ../LL_Shared_Source/: shared_lpf.c shared_lpf.h shared_pid.c shared_pid.h shared_pos_pid.c shared_pos_pid.h shared_source.h
  group user
    ../user/: isr.c isr.h main.c
